# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\driver;..\app;..\component\ringbuffer;..\app\font;..\driver\led;..\driver\key;..\driver\st7789;..\driver\timer;..\driver\esp_at;..\app\wifi;..\app\board;..\app\usart;..\app\weather;..\app\image;..\driver\tim_delay;..\app\page;..\driver\rtc;..\driver\aht20;..\third_lib\freertos\include;..\third_lib\freertos\portable;..\app\ui;..\app\workqueue
  memory RVCT4: ROM 0x8000000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c app.c
  group app/font
    ../app/font/: font16_maple.c font20_maple_bold.c font24_maple_bold.c font24_maple_semibold.c font32_maple_bold.c font54_maple_bold.c font54_maple_semibold.c font64_maple_extrabold.c font76_maple_extrabold.c
  group app/image
    ../app/image/: icon_duoyun.c icon_leizhenyu.c icon_na.c icon_qing.c icon_wenduji.c icon_wifi.c icon_yintian.c icon_yueliang.c icon_zhongxue.c icon_zhongyu.c img_error.c img_meihua.c img_wifi.c
  group app/page
    ../app/page/: error_page.c main_page.c welcome_page.c wifi_page.c
  group app/board
    ../app/board/: board.c
  group app/wifi
    ../app/wifi/: wifi.c
  group app/weather
    ../app/weather/: weather.c
  group app/usart
    ../app/usart/: usart.c
  group app/ui
    ../app/ui/: ui.c
  group app/workqueue
    ../app/workqueue/: workqueue.c
  group driver/led
    ../driver/led/: led.c
  group driver/timer
    ../driver/timer/: timer.c
  group driver/st7789
    ../driver/st7789/: st7789.c
  group driver/key
    ../driver/key/: key.c key_task.c
  group driver/esp_at
    ../driver/esp_at/: esp_at.c
  group driver/tim_delay
    ../driver/tim_delay/: tim_delay.c
  group driver/rtc
    ../driver/rtc/: rtc.c
  group driver/aht20
    ../driver/aht20/: aht20.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freertos
    ../third_lib/freertos/portable/: heap_4.c port.c
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group component/ringbuffer
    ../component/ringbuffer/: ringbuffer.c
